# EAGLE board RK05ex6x10 (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$57  (via drill 0.61) (continued)
  Bottom 0.508: v195.58,13.34 v211.46,13.34 | v195.58,20.95 194.94,21.59 v178.44,21.59 | v176.53,27.94 147.96,27.94 146.05,29.84 v143.51,29.84 | v127,71.12 120.02,71.12 117.47,73.66 58.42,73.66 57.78,74.3 v21.59,74.3
N$58
  Top 0.508: R32.2 220.98,24.77 220.98,23.5 D5.C 220.98,22.23 220.98,19.05 E13.5 221.62,17.14 221.62,14.61 226.69,14.61 230.5,10.79 E12.1
N$59
  Top 0.508: E16.3 139.7,11.43 142.24,13.97 142.24,16.51 E16.11
  Bottom 0.508: E15.3 164.47,9.53 163.19,8.26 159.38,8.26 158.75,8.89 158.75,15.88 144.15,15.88 142.88,17.14 E16.11
N$60
  Bottom 0.508: E23.13 18.41,42.55 19.68,41.27 28.57,41.27 29.84,42.55 E23.8
N$61  (via drill 0.61)
  Top 0.508: v234.95,46.99 234.95,22.86 238.76,19.05 E12.11 | v33.02,49.53 27.94,44.45 E23.9 | v21.59,48.26 21.59,45.72 20.32,44.45 E23.12
  Bottom 0.508: v234.95,46.99 231.14,50.8 173.99,50.8 173.35,50.16 148.59,50.16 147.96,49.53 v33.02,49.53 22.86,49.53 v21.59,48.26
N$62  (via drill 0.61)
  Top 0.508: v109.22,22.86 104.78,18.41 E17.11 | v121.92,23.5 133.35,12.06 137.16,12.06 137.16,11.43 E16.2
  Bottom 0.508: v109.22,22.86 109.86,23.5 v121.92,23.5
N$63  (via drill 0.61)
  Top 0.508: 106.05,15.88 103.5,15.88 102.23,17.14 E17.12 | 106.05,15.88 106.05,17.14 E17.10 | v242.57,6.99 242.57,15.24 241.3,16.51 E12.10 | v135.25,3.81 128.91,10.16 118.75,10.16 118.75,4.45 116.84,2.54 110.49,2.54 110.49,11.43 106.05,15.88
  Bottom 0.508: v242.57,6.99 239.4,3.81 v135.25,3.81
N$64  (via drill 0.61)
  Top 0.508: v140.97,48.26 140.97,64.77 133.99,71.75 v133.99,93.98
  Bottom 0.508: v140.97,48.26 165.1,48.26 169.54,43.81 E30.7 | v133.99,93.98 133.35,94.61 123.83,94.61 122.56,95.89 E26.6
N$65  (via drill 0.61)
  Top 0.508: v156.21,91.44 156.21,78.11 168.91,65.41 168.91,48.26 172.72,44.45 E30.6 | v128.91,92.71 125.73,95.89 125.73,101.6 124.46,102.87 E26.8
  Bottom 0.508: v156.21,91.44 154.94,92.71 v128.91,92.71
N$66  (via drill 0.61)
  Top 0.508: v142.24,83.19 142.24,76.83 151.13,67.94 151.13,41.91 153.67,39.37 153.67,8.26 168.28,8.26 168.91,8.89 168.91,33.02 170.18,34.29 E30.2 | v119.38,87.63 114.3,92.71 114.3,95.25 E26.3
  Bottom 0.508: v142.24,83.19 137.79,87.63 v119.38,87.63
N$67  (via drill 0.61)
  Top 0.508: v158.12,38.1 158.12,62.23 147.32,73.03 v147.32,74.93 | v131.44,78.74 v131.44,100.97
  Bottom 0.508: v158.12,38.1 165.1,38.1 167,36.2 E30.1 | v147.32,74.93 143.51,78.74 v131.44,78.74 | v131.44,100.97 126.36,106.05 118.75,106.05 117.47,104.78 E26.11
N$68  (via drill 0.61)
  Top 0.508: v152.4,59.05 152.4,44.45 E31.6
  Bottom 0.508: v152.4,59.05 151.13,60.33 140.34,60.33 E27.8
N$69  (via drill 0.61)
  Top 0.508: v147.32,50.8 149.86,48.26 149.86,44.45 E31.7
  Bottom 0.508: v147.32,50.8 139.7,50.8 137.79,52.7 E27.6
N$70  (via drill 0.61)
  Top 0.508: v134.62,44.45 128.27,50.8 128.27,55.24 132.08,59.05 132.08,59.69 E27.11
  Bottom 0.508: v134.62,44.45 140.97,38.1 144.78,38.1 146.69,36.2 E31.1
N$71
  Top 0.508: E27.3 129.54,52.07 135.89,45.72 135.89,33.02 141.6,27.3 149.22,27.3 149.22,34.92 E31.2
N$72
  Top 0.508: E32.7 109.22,44.45 111.76,46.99 111.76,52.07 E28.6
N$73
  Top 0.508: E32.2 108.58,34.92 107.31,33.66 105.41,33.66 105.41,44.45 106.05,45.09 106.05,50.16 104.14,52.07 E28.3
N$75  (via drill 0.61)
  Top 0.508: v37.47,85.09 37.47,74.3 33.02,69.85 E33.7 | v85.09,90.17 92.71,82.55 92.71,52.7 95.25,50.16 95.25,41.91 91.44,38.1 91.44,36.83 E29.6
  Bottom 0.508: v37.47,85.09 42.55,90.17 v85.09,90.17
N$76  (via drill 0.61)
  Top 0.508: v82.55,55.88 82.55,38.1 83.82,36.83 E29.3
  Bottom 0.508: v82.55,55.88 52.7,55.88 51.44,54.61 39.37,54.61 33.66,60.33 E33.2
N$77  (via drill 0.61)
  Top 0.508: v86.36,48.26 86.36,44.45 E29.11
  Bottom 0.508: v86.36,48.26 80.01,48.26 78.74,46.99 20.32,46.99 20.32,49.53 30.48,59.69 E33.1
N$78  (via drill 0.61)
  Top 0.508: v89.53,65.41 91.44,63.5 91.44,52.7 93.98,50.16 93.98,44.45 E29.8
  Bottom 0.508: v89.53,65.41 38.73,65.41 36.2,67.94 E33.6
N$80
  Top 0.508: E32.1 106.68,36.83 107.95,38.1 107.95,58.42 106.68,59.69 E28.11
N$81
  Top 0.508: E32.6 111.76,44.45 113.03,45.72 113.03,58.42 114.3,59.69 E28.8
N$82  (via drill 0.61)
  Top 0.508: E18.13 74.3,17.14 75.56,17.14 E18.12 | v211.46,41.27 199.39,53.34 v199.39,62.87 | v149.86,55.24 140.97,46.35 v140.97,45.72 | v104.78,45.72 102.87,43.81 v102.87,24.77 | v81.28,24.77 81.28,19.05 E18.10
  Bottom 0.508: E18.12 76.83,17.14 78.11,17.14 E18.11 79.38,17.14 80.64,17.14 E18.10 | v211.46,41.27 227.33,41.27 231.78,36.83 247.65,36.83 247.65,31.11 247.01,30.48 246.38,30.48 246.38,19.05 E12.8 | v199.39,62.87 185.42,62.87 184.15,64.14 173.35,64.14 171.45,62.23 171.45,55.24 v149.86,55.24 | v140.97,45.72 v104.78,45.72 | v102.87,24.77 v81.28,24.77
NEG1_DETECT_L
  Top 0.508: E23.6 27.94,36.83 25.4,39.37 25.4,41.91 E23.10
OSC_L  (via drill 0.61)
  Top 0.508: 127.64,27.3 v131.44,23.5 | 127.64,27.3 124.46,30.48 124.46,43.18 125.09,43.81 FUNCTION.3 | v137.16,23.5 137.16,19.05 E16.13 | v67.31,21.59 70.48,24.77 v70.48,25.4 | v126.36,26.04 127.64,27.3
  Bottom 0.508: v131.44,23.5 v137.16,23.5 | v67.31,21.59 55.24,21.59 53.98,22.86 R35.1 | v70.48,25.4 71.12,26.04 v126.36,26.04
RANDOM_L  (via drill 0.61)
  Top 0.508: v130.18,29.21 130.18,38.73 129.54,39.37 129.54,42.55 128.27,43.81 FUNCTION.4 | v88.9,22.23 v93.98,27.3 | R34.1 53.98,25.4 54.61,25.4 D1.C | v151.13,23.5 151.13,9.53 155.57,5.08 155.57,1.27 229.87,1.27 236.22,7.62 236.22,8.89 E12.3
  Bottom 0.508: v93.98,27.3 128.27,27.3 v130.18,29.21 141.6,29.21 145.41,25.4 149.22,25.4 v151.13,23.5 | v88.9,22.23 69.85,22.23 67.94,24.13 58.42,24.13 57.15,25.4 D1.C
READ_CLOCK
  Top 0.508: RN1.3 200.66,95.25 200.66,92.71 RN5.3 200.66,90.17 200.66,84.45 J1.F
READ_DATA
  Top 0.508: RN1.2 198.12,95.25 198.12,92.71 RN5.2 198.12,90.17 198.12,84.45 J1.D
REV_L  (via drill 0.61)
  Top 0.508: v99.06,13.97 99.06,16.51 E17.13 99.06,19.05 97.79,20.32 97.79,25.4 90.17,33.02 90.17,36.83 87.63,39.37 87.63,51.44 85.09,53.98 85.09,57.15 84.45,57.78 84.45,73.03 v82.55,74.93 | v64.77,74.93 64.77,84.45 63.5,85.72 R33.1
  Bottom 0.508: R33.1 62.87,86.36 62.23,87 59.69,87 FWD/REV.1 | v99.06,13.97 99.69,13.34 141.6,13.34 144.15,10.79 E16.5 | v82.55,74.93 v64.77,74.93
RK05_AU2  (via drill 0.61)
  Top 0.508: RN3.2 195.58,57.15 195.58,59.69 RN7.2 195.58,62.23 195.58,63.5 v191.13,67.94
  Bottom 0.508: v191.13,67.94 194.31,67.94 194.94,68.58 J2.A
RK05_BH2
  Top 0.508: RN2.4 236.22,95.25 236.22,92.71 RN6.4 236.22,90.17 236.22,84.45 J1.NN
RTZ_L  (via drill 0.61)
  Top 0.508: v102.23,6.99 99.69,9.53 E17.2 | v111.76,6.99 113.67,8.89 v113.67,11.43 | E22.7 43.18,44.45 43.18,79.38 RTZ.3 44.45,80.64 44.45,81.92 48.26,85.72 R24.1 | v55.88,6.99 54.61,8.26 54.61,19.05 53.34,20.32 50.8,20.32 v50.8,38.73
  Bottom 0.508: v111.76,6.99 v102.23,6.99 v55.88,6.99 | v113.67,11.43 134.62,11.43 E16.1 | v50.8,38.73 48.26,41.27 45.09,41.27 43.81,42.55 E22.7
RUN_L  (via drill 0.61)
  Top 0.508: v182.88,8.26 180.97,10.16 v180.97,33.02 | v144.78,33.66 138.43,40.01 138.43,66.04 132.72,71.75 v132.72,97.79
  Bottom 0.508: RUN.1 29.21,87 31.75,87 32.38,86.36 R19.1 33.66,86.36 45.72,98.42 132.08,98.42 v132.72,97.79 | v182.88,8.26 214,8.26 215.26,9.53 E13.2 | v180.97,33.02 180.34,33.66 v144.78,33.66
SECTOR_0L  (via drill 0.61)
  Top 0.508: v168.91,39.37 166.37,41.91 166.37,49.53 165.1,50.8 165.1,52.07 E3.1
  Bottom 0.508: v168.91,39.37 184.15,39.37 SECTOR.1
SECTOR_1L  (via drill 0.61)
  Top 0.508: v185.42,46.35 185.42,42.55 SECTOR.2 | v168.91,46.35 167.64,47.62 167.64,52.07 E3.2
  Bottom 0.508: v168.91,46.35 v185.42,46.35
SECTOR_2L  (via drill 0.61)
  Top 0.508: v187.96,48.9 187.96,45.09 188.59,44.45 SECTOR.3 | v171.45,48.9 170.18,50.16 170.18,52.07 E3.3
  Bottom 0.508: v171.45,48.9 v187.96,48.9
SECTOR_3L  (via drill 0.61)
  Top 0.508: v173.99,47.62 172.72,48.9 172.72,52.07 E3.4
  Bottom 0.508: v173.99,47.62 188.59,47.62 191.77,44.45 SECTOR.4
SECTOR_4L  (via drill 0.61)
  Top 0.508: v176.53,45.09 175.26,46.35 175.26,52.07 E3.5
  Bottom 0.508: v176.53,45.09 185.42,45.09 187.96,42.55 194.31,42.55 SECTOR.5
SECTOR_5L  (via drill 0.61)
  Top 0.508: v179.07,40.64 177.8,41.91 177.8,52.07 E3.6
  Bottom 0.508: v179.07,40.64 195.58,40.64 196.22,40.01 SECTOR.6
SECTOR_6L  (via drill 0.61)
  Top 0.508: v180.34,38.1 180.34,52.07 E3.7
  Bottom 0.508: v180.34,38.1 184.78,38.1 186.06,36.83 196.22,36.83 SECTOR.7
SECTOR_7L  (via drill 0.61)
  Top 0.508: v183.51,34.92 181.61,36.83 181.61,57.15 182.88,58.42 182.88,59.69 E3.9
  Bottom 0.508: v183.51,34.92 194.31,34.92 194.94,34.29 SECTOR.8
SECTOR_8L  (via drill 0.61)
  Top 0.508: v187.96,52.07 193.04,46.99 193.04,33.02 192.41,32.38 SECTOR.9
  Bottom 0.508: v187.96,52.07 184.78,55.24 176.53,55.24 175.9,55.88 175.9,59.05 176.53,59.69 176.53,62.87 178.44,62.87 179.71,61.59 E3.10
SECTOR_9L  (via drill 0.61)
  Top 0.508: v186.69,57.78 186.69,43.81 187.96,42.55 187.96,33.66 189.23,32.38 SECTOR.10
  Bottom 0.508: v186.69,57.78 180.97,57.78 178.44,60.33 E3.11
SECTOR_SELECT_L  (via drill 0.61)
  Top 0.508: v194.31,38.1 194.94,38.73 194.94,40.64 196.22,41.91 196.22,48.26 188.59,55.88 188.59,57.15 187.96,57.78 187.96,59.69 185.42,62.23 185.42,66.04 183.51,67.94 v183.51,71.75 | v139.7,73.66 137.16,76.2 137.16,95.25 E7.1
  Bottom 0.508: v194.31,38.1 SECTOR.C | v183.51,71.75 182.88,72.39 153.67,72.39 152.4,73.66 v139.7,73.66
SEEK_INCOMPLETE_L  (via drill 0.61)
  Top 0.508: v53.34,54.61 53.34,59.69 E21.3 | v86.36,54.61 88.27,56.52 88.27,84.45 87,85.72 SEEK_INC.B
  Bottom 0.508: v53.34,54.61 v86.36,54.61
SELECT_0L  (via drill 0.61)
  Top 0.508: v57.15,53.34 57.15,40.01 DRIVE.1 | v142.24,55.24 148.59,61.59 v148.59,64.77 | v201.93,66.67 201.93,54.61 209.55,46.99 209.55,46.35 210.19,45.72 212.09,45.72 v212.09,57.78 | RN4.10 223.52,57.15 223.52,59.69 RN8.10 223.52,62.23 223.52,67.94 J2.AA
  Bottom 0.508: v57.15,53.34 94.61,53.34 96.52,55.24 v142.24,55.24 | v148.59,64.77 149.22,65.41 182.25,65.41 183.51,66.67 v201.93,66.67 | v212.09,57.78 217.17,57.78 218.44,56.52 222.88,56.52 RN4.10
SELECT_1L  (via drill 0.61)
  Top 0.508: v66.67,40.01 66.67,41.91 59.05,41.91 DRIVE.2 | v93.98,38.73 97.79,42.55 v97.79,48.26 | v128.27,48.26 134.62,41.91 134.62,33.02 141.6,26.04 152.4,26.04 v152.4,25.4 | v186.69,24.13 187.96,25.4 187.96,29.84 188.59,30.48 190.5,30.48 190.5,36.2 189.23,37.47 189.23,42.55 190.5,43.81 v190.5,47.62 | v218.44,49.53 218.44,52.7 R69.1 218.44,53.98 218.44,57.78 R70.2 218.44,59.05 218.44,67.94 J2.W
  Bottom 0.508: v66.67,40.01 67.94,38.73 v93.98,38.73 | v128.27,48.26 v97.79,48.26 | v152.4,25.4 153.67,24.13 v186.69,24.13 | v190.5,47.62 192.41,49.53 v218.44,49.53
SELECT_2L  (via drill 0.61)
  Top 0.508: v67.94,114.94 67.94,50.8 61.59,44.45 DRIVE.3 | v186.06,103.5 191.77,97.79 v191.77,80.64 | v242.57,78.74 243.84,77.47 243.84,74.3 247.01,71.12 v247.01,66.67 | v227.33,53.98 v227.33,65.41 | RN3.9 213.36,57.15 213.36,59.69 RN7.9 213.36,62.23 213.36,67.94 J2.S
  Bottom 0.508: v67.94,114.94 69.22,116.2 173.35,116.2 v186.06,103.5 | v191.77,80.64 193.68,78.74 v242.57,78.74 | v247.01,66.67 245.75,65.41 v227.33,65.41 | v227.33,53.98 222.25,53.98 221.62,54.61 217.17,54.61 216.53,53.98 215.26,53.98 214,55.24 RN3.9
SELECT_3L  (via drill 0.61)
  Top 0.508: v96.52,43.18 96.52,51.44 97.79,52.7 v97.79,56.52 | v170.18,56.52 171.45,57.78 171.45,65.41 170.81,66.04 v170.81,73.66 | RN3.7 207.65,56.52 207.01,57.15 207.01,59.69 207.65,60.33 RN7.7 208.28,62.23 208.28,67.94 J2.M
  Bottom 0.508: v96.52,43.18 93.34,40.01 79.38,40.01 77.47,41.91 75.56,41.91 73.03,44.45 65.41,44.45 DRIVE.4 | v170.18,56.52 v97.79,56.52 | v170.81,73.66 172.09,74.93 241.94,74.93 248.92,67.94 249.56,67.94 250.19,67.31 250.19,64.14 219.07,64.14 217.81,62.87 210.19,62.87 208.91,61.59 RN7.7
STEP_L  (via drill 0.61)
  Top 0.508: R37.1 71.12,5.71 71.12,8.89 E18.1 71.12,11.43 66.04,16.51 66.04,24.77 D1.A 66.67,26.04 66.67,27.94 v70.48,31.75 | v111.76,38.73 110.49,37.47 v110.49,32.38
  Bottom 0.508: v111.76,38.73 120.02,38.73 120.65,39.37 FUNCTION.1 | v110.49,32.38 109.86,31.75 v70.48,31.75
VCC  (via drill 0.61)
  Top 0.508: C21.1 46.35,68.58 47.62,68.58 E21.8 48.26,69.85 48.26,75.56 R24.2 48.9,76.2 50.16,76.2 R36.2 | C33.1 27.94,61.59 27.94,64.77 30.48,67.31 E33.8 30.48,69.85 30.48,73.03 33.02,75.56 R19.2 | R34.2 43.18,24.77 43.18,23.5 R35.2 43.18,22.23 43.18,19.05 E19.16 | 39.37,43.18 38.73,43.18 C22.1 | 39.37,43.18 40.01,43.18 E22.8 | E20.16 15.24,19.05 16.51,20.32 16.51,40.64 15.24,41.91 E23.14 15.24,44.45 15.24,48.26 19.68,52.7 C68.+ | 39.37,43.18 39.37,19.68 40.64,18.41 C19.1 | C3.1 163.19,60.96 164.47,60.96 E3.16 165.1,59.69 163.83,58.42 163.83,45.09 165.1,43.81 C30.1 | E31.8 146.69,43.18 145.41,43.18 C31.1 | C17.1 94.61,17.78 95.89,17.78 E17.14 96.52,16.51 95.25,15.24 95.25,5.08 | E18.14 70.48,17.78 69.22,17.78 C18.1 | 95.25,5.08 95.89,5.08 R26.2 | 95.25,5.08 81.92,5.08 R37.2 80.64,5.08 77.47,8.26 77.47,11.43 71.75,17.14 E18.14 | C27.1 121.92,61.59 120.02,63.5 120.02,77.47 117.47,80.01 POWER.2 | E28.14 98.42,60.96 97.16,60.96 C28.1 | E18.14 71.12,19.05 71.75,19.68 71.75,62.87 C67.+ | R33.2 63.5,75.56 63.5,71.12 64.77,69.85 64.77,60.96 63.5,59.69 D2.A | C41.1 248.28,55.88 247.01,55.88 RN4.1 | RN3.1 192.41,55.88 191.13,55.88 C40.1 190.5,56.52 189.23,57.78 189.23,61.59 189.87,62.23 189.87,69.22 189.23,69.85 189.23,82.55 188.59,83.19 C52.+ 187.32,84.45 v187.32,98.42 | C16.1 132.72,17.78 133.99,17.78 E16.14 134.62,19.05 135.89,20.32 v135.89,20.95 | E15.14 159.38,17.78 158.12,17.78 C15.1 157.48,18.41 v154.94,20.95 | E13.8 212.72,17.78 211.46,17.78 C13.1 | 229.87,17.78 229.24,17.78 C12.1 | 229.87,17.78 230.5,17.78 E12.14 | E14.16 184.78,17.78 183.51,17.78 C14.1 | R28.2 189.87,5.08 186.69,8.26 186.69,15.24 185.42,16.51 E14.16
  Top 0.508: R25.2 185.42,24.77 185.42,19.05 E14.16 | 229.87,17.78 229.87,49.53 231.14,50.8 231.14,52.7 R147.2 | R17.2 127,126.36 127,122.56 124.46,120.02 R45.1 125.09,119.38 128.27,116.2 128.27,115.57 134.62,109.22 134.62,104.78 C7.1 135.25,104.14 135.89,104.14 | C10.1 74.3,139.7 75.56,139.7 E10.14 76.2,138.43 77.47,137.16 77.47,121.28 78.74,120.02 R42.1 | C11.1 48.9,139.7 50.16,139.7 E11.14 50.8,138.43 49.53,137.16 49.53,121.28 48.26,120.02 R40.1 | E9.14 24.77,139.7 23.5,139.7 C9.1 22.86,139.06 17.78,133.99 17.78,120.02 R38.1 | C26.1 106.68,104.78 106.68,116.2 109.22,118.75 R44.1 | C60.+ 37.47,97.16 34.29,100.33 34.29,117.47 33.02,118.75 R39.1 | R46.2 233.04,99.06 231.14,100.97 R50.2 231.14,102.23 231.14,113.67 236.22,118.75 R5.2 | C43.1 245.75,96.52 244.47,96.52 RN2.1 | E1.14 230.5,139.7 229.24,139.7 C1.1 228.6,140.34 228.6,141.6 226.06,144.15 | 226.06,144.15 R10.2 226.06,144.15 | E2.14 205.1,139.7 203.84,139.7 C2.1 | R13.2 175.26,125.09 175.26,126.36 R12.2 175.26,127.64 179.07,131.44 179.07,139.7 | 179.07,139.7 178.44,139.7 C4.1 | 179.07,139.7 179.71,139.7 E4.14 | 226.06,144.15 226.06,125.09 220.98,120.02 R7.2 | 135.89,104.14 136.53,104.14 E7.14 | 135.89,104.14 135.89,72.39 136.53,71.75 C61.+ | C42.1 193.68,96.52 194.94,96.52 RN1.1 | v160.02,97.79 160.02,89.53 R6.2 | E24.14 100.97,139.7 99.69,139.7 C24.1 | R18.2 122.56,139.7 123.83,139.7 C6.1 125.09,139.7 126.36,139.7 E6.14 | R11.2 149.86,144.15 149.86,140.34 C8.1 150.5,139.7 151.76,139.7 E8.16 152.4,138.43 153.67,137.16 153.67,130.81 157.48,127 157.48,125.09 R8.2 157.48,123.83 162.56,118.75 162.56,104.78 C5.1 163.19,104.14 164.47,104.14 E5.14 165.1,102.87 165.1,97.79 E5.1
  Bottom 0.508: R33.2 62.87,76.2 51.44,76.2 R36.2 | C68.+ 20.95,53.98 27.3,60.33 27.94,60.33 C33.1 | R24.2 47.62,76.2 33.66,76.2 R19.2 33.02,76.83 33.02,81.92 26.67,81.92 25.4,83.19 25.4,95.89 37.47,95.89 C60.+ | E32.8 106.05,43.18 104.78,43.18 C32.1 103.5,43.18 101.6,45.09 80.64,45.09 79.38,43.81 E29.14 78.11,43.18 76.83,43.18 C29.1 75.56,43.18 73.03,45.72 43.18,45.72 41.27,43.81 E22.8 | E19.16 42.55,17.78 41.27,17.78 C19.1 | E20.16 14.61,17.78 13.34,17.78 C20.1 | C23.1 13.34,43.18 14.61,43.18 E23.14 15.88,43.81 17.14,45.09 35.56,45.09 37.47,43.18 C22.1 | E30.8 167,43.18 165.74,43.18 C30.1 164.47,43.18 162.56,45.09 149.22,45.09 147.96,43.81 E31.8 | E27.14 123.83,60.96 122.56,60.96 C27.1 121.28,60.96 119.38,62.87 | D2.A 64.14,58.42 65.41,58.42 R27.2 66.04,59.05 68.58,61.59 | 68.58,61.59 69.85,62.87 70.48,62.87 C67.+ | 68.58,61.59 95.25,61.59 95.89,60.96 C28.1 | 119.38,62.87 100.97,62.87 99.69,61.59 E28.14 | 119.38,62.87 140.34,62.87 141.6,61.59 161.29,61.59 161.93,60.96 C3.1 | RN4.1 245.75,55.24 244.47,53.98 232.41,53.98 231.78,53.34 R147.2 230.5,53.34 229.24,52.07 210.19,52.07 208.91,53.34 R69.2 207.65,53.34 207.01,53.98 194.94,53.98 193.68,55.24 RN3.1 | v154.94,20.95 v135.89,20.95 | E13.8 214,17.14 215.26,15.88 226.06,15.88 227.97,17.78 C12.1 | 187.32,15.88 208.28,15.88 210.19,17.78 C13.1 | 187.32,15.88 186.06,17.14 E14.16 | 187.32,15.88 161.93,15.88 160.66,17.14 E15.14 | E26.14 108.58,104.14 107.31,104.14 C26.1 | 33.02,120.02 19.05,120.02 18.41,119.38 R38.1 | 33.02,120.02 R39.1 33.02,120.02 | 33.02,120.02 46.99,120.02 47.62,119.38 R40.1 48.26,120.02 62.23,120.02 62.87,119.38 R41.1 63.5,120.02 77.47,120.02 78.11,119.38 R42.1 78.74,120.02 92.71,120.02 93.34,119.38 R43.1 93.98,120.02 107.95,120.02 108.58,119.38 R44.1 109.22,120.02 123.19,120.02 123.83,119.38 R45.1
  Bottom 0.508: R7.2 221.62,119.38 222.25,120.02 236.22,120.02 R5.2 | RN2.1 243.21,95.89 241.94,95.89 RN2.2 240.66,97.16 239.4,98.42 234.95,98.42 234.31,99.06 R46.2 | 200.66,141.6 202.56,139.7 C2.1 | 200.66,141.6 182.25,141.6 180.97,140.34 E4.14 | 200.66,141.6 226.06,141.6 227.97,139.7 C1.1 | E7.14 137.16,105.41 139.06,107.31 142.24,107.31 144.15,109.22 R4.2 145.41,109.22 148.59,106.05 160.02,106.05 161.93,104.14 C5.1 | v160.02,97.79 165.1,97.79 E5.1 165.74,97.16 167,98.42 170.81,98.42 | 170.81,98.42 172.09,97.16 E5.4 | 170.81,98.42 v187.32,98.42 190.5,98.42 192.41,96.52 C42.1 | E24.14 102.23,140.34 103.5,141.6 119.38,141.6 121.28,139.7 R18.2 | R9.A 153.67,147.32 151.13,144.78 150.5,144.78 R11.2 149.22,144.78 147.32,146.69 R16.2 146.69,147.32 140.97,141.6 128.91,141.6 127.64,140.34 E6.14 | R13.2 174.62,124.46 173.35,123.19 159.38,123.19 158.12,124.46 R8.2
WRITE_GATE
  Top 0.508: E2.1 205.74,133.35 208.28,135.89 208.28,138.43 E2.13 | E8.2 155.57,131.44 156.84,131.44 E8.3 | E8.11 164.47,139.06 158.12,132.72 E8.3 | E5.13 167.64,105.41 167.64,121.92 158.12,131.44 E8.3
  Bottom 0.508: E9.11 33.66,139.06 37.47,135.25 57.78,135.25 60.33,132.72 E11.5 61.59,132.72 62.87,133.99 153.03,133.99 154.31,132.72 E8.2 | E2.13 207.65,139.06 206.38,137.79 167,137.79 165.74,139.06 E8.11
WRITE_H  (via drill 0.61)
  Top 0.508: v163.83,99.69 163.83,88.27 WRITE_BUTTON.1 | v82.55,124.46 82.55,137.16 81.28,138.43 E10.12
  Bottom 0.508: v163.83,99.69 200.03,99.69 | 200.03,99.69 226.06,99.69 235.59,109.22 R5.1 | v82.55,124.46 84.45,122.56 124.46,122.56 126.36,120.65 154.31,120.65 154.94,120.02 179.71,120.02 200.03,99.69
WRITE_L  (via drill 0.61)
  Top 0.508: v95.25,99.69 95.25,132.08 88.9,138.43 E10.9 | v158.75,99.69 158.75,80.64 160.02,79.38 R6.1
  Bottom 0.508: v158.75,99.69 v95.25,99.69 | WRITE_BUTTON.3 163.83,79.38 163.19,78.74 160.66,78.74 R6.1

## Text on the board
Top: RK05 Exerciser | VRS
Bottom: VRS | RK05 Exerciser
tPlace: Note: SIP resistors must be 200mW parts
Document: TODO: Orient switch footprints | TODO: Use PC supply?